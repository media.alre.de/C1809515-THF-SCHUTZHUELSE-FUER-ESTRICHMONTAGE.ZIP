Properties of the parts of a building model (IFC4)

# File
Description: Schutzhülse für Estrichmontage Hülsen-/Kabelfühler, Kupfer, Durchmesser Innen 7,7 mm, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: C1809515, Schutzhülse für Estrichmontage Hülsen-/Kabelfühler, Kupfer, Durchmesser Innen 7,7 mm
In: Raum
Description: Cu-Schutzhülse für Hülsenfühler HF / Kabelfühler KF zur Estrichmontage. Kupfer, Durchmesser Innen 7,7mm; Classification: EC010502 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: C1809515; ModelLabel: THF; GlobalTradeItemNumber: 4050528018441; ProductURL: https://alre.de/produkt_C1809515
Pset_Specification - NominalLength: 0.117 m; NominalWidth: 0.021 m; NominalDepth: 0.021 m; NetWeight: 0.03
Pset_ALRE_ETIM_Properties - Außendurchmesser: 10; Innendurchmesser: 8; Material Tauchrohr: sonstige; Einstecklänge: 117; ETIM-Klasse: EC010502; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-C1809515.pdf
